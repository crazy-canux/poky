inherit pypi setuptools3
require python-pymysql.inc
