inherit setuptools3
require python-python-iptables.inc
